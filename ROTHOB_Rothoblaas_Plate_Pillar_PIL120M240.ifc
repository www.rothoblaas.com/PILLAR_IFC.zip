Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 7766e88a-8998-4cbe-8050-1c19ffa03569, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Structural]
File name: Project Number
Time: 2024-06-21T14:53:02+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Level Head - FFL (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level Head - FFL; Type: Level Head - FFL; Type Id: 146979
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level Head - FFL
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 3000

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_Plate_Pillar:PIL120M240_280x405x280mm, ROTHOB_Rothoblaas_Plate_Pillar:PIL120M240_280x405x280mm:434237
In: Level 2
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated, <Unnamed>
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-19/0700; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Column-to-floor connection system; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_Pillar; Features: SPIDER and PILLAR connectors for load bearing connections between timber, steel or concrete columns and CLT floors.; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 81.845 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: PIL120M240; ModelReference: n/a; Name: Plate; NominalHeigth: 405 mm; NominalLength: 280 mm; NominalWidth: 280 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 280x405x280 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 1202
Type - Dimensions - BottomPlateDiameter_Dbp: 280 mm; BottomPlateHoleDistance: 70 mm; BottomPlateThickness_tbp: 40 mm; CLTPanelThickness_tCLT: 240 mm; CylinderDiameter_Dcyl: 120 mm; DiscDiameter: 200 mm; DiscInnerDiameter: 21 mm; DiscThickness: 15 mm; FasteningPlateDiameter: 250 mm; FasteningPlateInnerDiameter: 122 mm; FasteningPlateThickness: 6 mm; ObjectHeight: 405 mm; UpperPlateDiameter_Dtp: 280 mm; UpperPlateHoleDistance: 35 mm; UpperPlateThickness_ttp: 40 mm
Type - General - Author: Vitor Ferronato; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/clt-floor-column-connections/pillar#PILLAR; Revision: 1; UniClass2015Code: Pr_20_85_09_11; UniClass2015Title: Carbon steel brackets; UniClass2015Version: Products v1.33; Version: 3
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: PIL120M240_280x405x280mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate
Pset_BuildingElementProxyCommon - Reference: PIL120M240_280x405x280mm; sets with these values: 2
Other - Family: ROTHOB_Rothoblaas_Plate_Pillar; Family and Type: ROTHOB_Rothoblaas_Plate_Pillar: PIL120M240_280x405x280mm; Type: PIL120M240_280x405x280mm; Type Id: 434185
Constraints - Elevation from Level: -3000 mm; Host: <not associated>; Level: Level 2; Schedule Level: Level 2
Dimensions - Volume: 0.0104759 m3
Phasing - Phase Created: New Construction
